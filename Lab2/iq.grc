options:
  parameters:
    author: osboxes
    generate_options: qt_gui
    id: iq
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quadrature_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_2
  id: audio_sink
  parameters:
    device_name: hw:0,0
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/sf_EE340/lab_1-20230806/background.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /media/sf_EE340/lab_1-20230806/vocal.wav
    repeat: 'True'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: '960000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: '960000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '9600'
    interp: '441'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Modulated
    label1: Demodulated
    num_tabs: '2'
  states: {}

connections:
- [analog_sig_source_x_2, '0', blocks_add_xx_1, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_3, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_1_0_0, '0']
- [blocks_multiply_xx_2, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_3, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_1_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_2, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_xx_3, '0']
- [rational_resampler_xxx_1_0_0, '0', audio_sink_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0

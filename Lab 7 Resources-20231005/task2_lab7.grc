options:
  parameters:
    author: osboxes
    generate_options: qt_gui
    id: task1_BPSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '3'
    step: '1'
    stop: '3'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: sps
  id: variable_qtgui_range
  parameters:
    start: '8'
    step: '1'
    stop: '8'
    value: '8'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*5
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/sf_EE_340/Lab 7 Resources-20231005/Original_Text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@0
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: tab@2
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@0
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@3
    size: '1024'
    srate: samp_rate*5
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: gain
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Original_File
    label1: before_rrc
    label2: after_rrc
    label3: eye
    label4: Transmitted_signal
    num_tabs: '5'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
